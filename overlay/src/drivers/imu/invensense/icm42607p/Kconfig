## overlay/src/drivers/imu/invensense/icm42607p/Kconfig
```kconfig
menuconfig DRIVERS_IMU_INVENSENSE_ICM42607P
	bool "icm42607p"
	default n
	---help---
		Enable support for icm42607p
```
